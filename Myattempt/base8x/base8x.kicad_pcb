# Repository sam-mendis/hardware (continued)

## KiCad design KiCAD/base1x/base1x.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C11, C14, C15, C16, C17, C18: 0.1uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder; farnell code 1759297
C9, C10: 10uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder; farnell code 1759453
C12, C13: 47uF; CP_EIA-7343-43_Kemet-X_Pad2.25x2.55mm_HandSolder; farnell code 2671886
D1, D2: BPW21; farnellCode 1045427
D3, D4, D5, D6, D7, D8, D9, D10: FDH333; D_DO-35_SOD27_P7.62mm_Horizontal; farnellCode 9843760
J1, J16: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical; farnellCode 2215304
J2, J4, J5, J10, J11, J12, J13, J14, J17, J18, J19, J20: Conn_01x03; PinHeader_1x03_P1.27mm_Vertical; farnell code 2578712+2505013
J3: Conn_02x14_Counter_Clockwise; PinSocket_2x14_P2.54mm_Vertical; farnell code 1097986
J6: Conn_01x14_Counter_Clockwise; PinSocket_1x14_P2.54mm_Vertical; farnellCode 1593466
J7, J8: Conn_02x06_Counter_Clockwise; PinHeader_2x06_P2.54mm_Vertical
J9: Screw_Terminal_01x08; PhoenixContact_MC_1,5_8-GF-3.5_1x08_P3.50mm_Horizontal_Thre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; farnellCode 2776340+1793014
J15: Conn_01x08; Converter_DCDC_TRACO_TMR-xxxx_THT; Farnell Code 495-TMR6-0521
JP1, JP2: Jumper_NC_Small; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3, JP4: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: grey@mutovis.com; text
MK1, MK2: Mounting_Hole_PAD; MountingHole_2.2mm_M2_Pad
MK3, MK4: Mounting_Hole; MountingHole_6mm
MK5, MK7, MK8, MK9, MK10, MK11, MK12, MK13, MK14: Mounting_Hole; MountingHole_3.2mm_M3
MK6: Mounting_Hole; MountingHole_4.3mm_M4
R1: 20R; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder; farnellCode 1887405
R2, R3, R6: 1k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder; farnellCode 2447473
R4, R5, R11: 51R; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder; farnellCode 2695165
TP1, TP2, TP3, TP4, TP5, TP6, TP7: Test_Point; Test_Point_S1751-46R; farnellCode 2293786
U1: AD8616; SOIC-8_3.9x4.9mm_P1.27mm; farnell code 1581952
U2, U5: ads122c04; TSSOP-16_4.4x5mm_P0.65mm; Farnell Code 296-50885-1-ND
U3: AD8615; TSOT-23-5; farnell code 2305615
U8: LT1963EQ-2.5; TO-263-5_TabPin3; Farnell Code LT1963EQ-2.5#PBF-ND
U9: LT3015EQ-2.5; TO-263-5_TabPin3; Farnell Code 584-LT3015EQ-2.5#PBF

Connections:
+2V5: C1.1, C4.2, C8.1, C16.1, J9.3, JP1.2, U1.8 (V+), U2.12 (AVDD), U3.5 (V+), U5.12 (AVDD)
+3V3: J3.3, J3.4
+5V: C7.1, C14.1, J1.2, J3.1, J3.2, J14.3, J15.2, J16.2, U2.1 (A0), U2.3 (~RESET), U2.13 (DVDD), U5.3 (~RESET), U5.13 (DVDD)
+5VA: C10.1, J15.6, U8.1 (~SHDN), U8.2 (IN)
-2V5: C2.1, C5.2, C11.1, C17.1, J9.4, JP2.2, U1.4 (V-), U2.5 (AVSS), U3.2 (V-), U5.5 (AVSS)
-5VA: C9.1, J15.8, U9.1 (~SHDN), U9.3 (IN)
/EnableTraco: J1.5, J15.3, J16.5
/V_Current: R11.2, U2.10 (AIN1)
/V_D1: R5.2, U2.7 (AIN2)
/V_D2: R4.2, U2.6 (AIN3)
/Vin: J9.2, J14.2, JP3.1, JP4.1
GND: C7.2, C14.2, J1.6, J3.19, J3.20, J9.1, J13.1, J15.1, J16.6, MK1.1, MK2.1, TP1.1, U2.2 (A1), U2.4 (DGND), U5.1 (A0), U5.2 (A1), U5.4 (DGND)
GNDREF: C1.2, C2.2, C4.1, C5.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C16.2, C17.2, D1.2 (A), D2.2 (A), J2.3, J13.2, J14.1, J15.7, J17.2, TP7.1, U1.3 (+), U1.5 (+), U8.3 (GND), U9.2 (GND)
I+: J3.21, J9.8, J10.2, J18.2, J19.2
I-: J3.27, J4.2, J5.2
I-_EXT: D9.2 (A), D10.1 (K), J2.1, J4.1, J9.5, J17.3
MISO: J1.1, J3.13, J3.14, J16.1
MOSI: J1.4, J3.15, J3.16, J16.4
unnamed: C3.1, J20.1, R1.1
unnamed: C3.2, C6.2, J4.3, R1.2, R6.1, U3.4 (-)
unnamed: C6.1, J20.3, R6.2
unnamed: C12.1, JP1.1, TP5.1, U8.4 (OUT), U8.5 (SENSE)
unnamed: C13.2, JP2.1, TP6.1, U9.4 (SENSE), U9.5 (OUT)
unnamed: C15.1, D2.1 (K), R2.2, U1.6 (-)
unnamed: C15.2, R2.1, R4.1, TP4.1, U1.7
unnamed: C18.1, D1.1 (K), R3.2, U1.2 (-)
unnamed: C18.2, R3.1, R5.1, TP3.1, U1.1
unnamed: D3.1 (K), J18.1
unnamed: D3.2 (A), D5.1 (K)
unnamed: D4.1 (K), D6.2 (A)
unnamed: D4.2 (A), J19.1
unnamed: D5.2 (A), D7.1 (K)
unnamed: D6.1 (K), D8.2 (A)
unnamed: D7.2 (A), D9.1 (K)
unnamed: D8.1 (K), D10.2 (A)
unnamed: J1.9, JP3.2
unnamed: J2.2, U3.3 (+)
unnamed: J5.1, U5.6 (AIN3)
unnamed: J10.1, U5.7 (AIN2)
unnamed: J11.1, U5.11 (AIN0)
unnamed: J12.1, U5.10 (AIN1)
unnamed: J16.9, JP4.2
unnamed: J20.2, R11.1, TP2.1, U3.1
SCK: J1.3, J3.17, J3.18, J16.3
SCL: J1.8, J3.9, J3.10, J16.8, U2.16 (SCL), U5.16 (SCL)
SDA: J1.7, J3.7, J3.8, J16.7, U2.15 (SDA), U5.15 (SDA)
V+: J3.23, J9.7, J11.2
V-: J3.25, J9.6, J12.2
V_D: J3.5, J3.6, U2.11 (AIN0)
~CS0: J1.10, J3.11, J16.10

Notes on the sheet:
LEFT SIDE BUS CONNECTIONS
COMM_BUS
To Sourcemeter
External Power
TRACO POWER TMR 6-0521
Overvoltage Protection
The Ds here could optionally be 2x TZX2V7A or 8x MUR120-T
Float I-
Tie Grounds
Protect
Molex Vin Select
Use External TIA GND
Disable TIA
FDH333 : 500mA of protection, 2x3nA of leakage TZX2V7A : 185mA, 5uA MUR120-T : 1000mA, 2x2uA
Diagnose I+
Diagnose I-
Diagnose V+
Diagnose V-
Cell Current Transimpedance Amplifier
Gain=20V/A or 1000V/A (dark mode)
Controller Mounts
Pi Mounts
Arduino Mounts
Photodiode Transimpedance Amplifiers
Analog Power Supplies
Current and Adapter Sense ADC
Connection Health and Voltage ADC
Consider switching to LT1997-1 (this TIA limits current to 150mA)
COMM_BUS_MIRROR
1 Sun -> ~~1mA through the PD -> ~~1V to the ADC

Board: 4 copper layers, 130.0 x 110.0 mm, 87 parts (10 on the bottom side), 50 nets.

Other parts of the board:
logo: G***; logo

## KiCad design KiCAD/springPins25x25DBG/springPins25x25DBG.kicad_pcb

Board: 2 copper layers, 25.0 x 25.0 mm, 18 parts (5 on the bottom side), 14 nets.

Parts:
J1, J2: CONN_02X06; PinHeader_2x06_P2.54mm_Vertical
JP1: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1, L1#2: GREY@CHRISTOFORO.NET; logo_small
R1: 200k; R_1206_3216Metric
TP3, TP4, TP5, TP6, TP7, TP8, TP15, TP16, TP17, TP18, TP19, TP20: TEST; S25-022+P25-4023

Connections:
/BCu: J2.3, JP1.1
/FCu: J2.1, JP1.2
/I1: J2.2, J2.4, TP20.1
/I2: J1.1, J1.3, TP8.1
/I3: J2.6, J2.8, TP18.1
/I4: J1.5, J1.7, TP6.1
/I5: J2.10, J2.12, TP15.1
/I6: J1.9, J1.11, TP3.1
/IB: J2.7, TP19.1
/IT: J1.8, TP4.1, TP17.1
/RH: J1.2, R1.2
/RL: J1.4, R1.1
/VB: J2.5, TP7.1
/VT: J1.6, TP5.1, TP16.1

## KiCad design KiCAD/megaHalfShield/megaHalfShield.kicad_pcb

Board: 2 copper layers, 35.1 x 53.3 mm, 10 parts (0 on the bottom side), 10 nets.

Parts:
J1: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
J2: Conn_01x01; PinSocket_1x01_P2.54mm_Vertical
L1: GREY@CHRISTOFORO.NET; logo
P1: Digital; Socket_Strip_Arduino_2x18
P4: Analog; Socket_Strip_Arduino_1x08
P7: Communication; Socket_Strip_Arduino_1x08
P10, P13: CONN_01X01; Arduino_1pin
R1, R2: 100K; R_1206_3216Metric

Connections:
+5V: J1.2, P1.35, P1.36, R1.2, R2.2
/Vin: J1.9, J2.1
GND: J1.6, P1.1, P1.2
MISO: J1.1, P1.5
MOSI: J1.4, P1.6
SCK: J1.3, P1.3
SCL: J1.8, P7.8, R2.1
SDA: J1.7, P7.7, R1.1
V_D_EXT: J1.5, P4.8
~CS0: J1.10, P1.7

## Commit log

2016-10-20 formatting
2016-10-20 add bom and kicad project files for 8x1 probe board
2016-10-20 add layout file
2016-10-20 mux and 8x1 probe design started
2016-10-21 add pin mapping table
2016-10-21 8x1 probe schematic "done"
2016-10-26 single board prototype design almost done need to finish routing
2017-01-15 backplane v0.20 order placed
2017-01-17 switch adapter board mounting
2017-01-18 properly link mounting holes to schematic
2017-01-19 adapter board done
2017-01-26 28x28 mux adapter done28x28 mux adapter done
2017-01-31 order placed for 28x28 mux boards without blind vias
2017-02-02 fix diode sense resistor
2017-02-08 fix some issues with the mux adapter board order
2017-02-16 add voltera fix
2017-02-18 fix up some hardware bugs
2017-03-12 start work on distributor boards
2017-03-13 1x distro board wired
2017-03-17 tight spacing 30x30x5 distributor boards done
2017-03-30 distributor 8A layout done
2017-03-30 distributor 8B layout done
2017-04-04 8ch distributor board done
2017-04-06 30x30 spring pin adapter board done
2017-04-13 switch to step for 3d
2017-04-20 better assembler
2017-04-25 change d8 header
2017-04-25 fix board assembly
2017-04-25 fix 28x28 adapter chip width
2017-04-25 update board silkscreen version
2017-04-25 remove voltera outputs
2017-04-25 try to fix messed up d8 routing
2017-04-25 fixed d8
2017-04-25 remove unneeded files
2017-04-25 updage silkscreen hash and gen manufacturing files
2017-04-26 mux8 done
2017-04-26 minor text changes to mux8 pcb
2017-04-26 mux 8 done
2017-05-04 backplane 8 d
2017-05-04 fix silk
2017-05-04 update commit silk
2017-05-04 fix plane8 connector spacing
2017-05-04 add mounting holes
2017-05-04 update plane8 commit silk
2017-05-11 made new photodiode array, fixed springpin board
2017-05-11 generate order packages
2017-05-11 move spring pins out
2017-05-11 update silk
2017-05-31 fix pwr/gnd swap, fix extra clock signal name, fix pin hole sizes
2017-05-31 update 30x30 silk
2017-08-23 adding new spring pin boards
2017-08-23 new 28x28 spring pin board done
2017-08-24 nowindow pin boards done
2017-08-24 fix gitignore
2017-09-07 new mux schematic mostly done
2017-09-15 new mux done
2017-09-18 generate order zip and silk for newMUX
2017-09-18 spruce up 28x28NoWindow
2017-09-18 28x28noWindow new silk and order.zip
2017-09-18 30x30NoWindow spruce up
2017-09-25 base1x schemaic mostly done
2017-09-26 fixed some no-connect bugs in newMux
2017-09-26 updated newMUX silk
2017-10-05 fixed up newMux so that parts don't collide
2017-10-11 wip for base1x
2017-11-03 adding schematic for ALD control circuit
2017-11-07 make spring pin board pin holders smaller, update base1x, update mux design controller board
2017-11-07 soleoid_schematic_20171107
2017-11-10 fix solentoid sch
2017-12-17 wip commit
2017-12-28 add arduino mega half-shield
2018-02-15 Better design for ALD Control electronics
    More space and cost-efficient circuit design for ALD control electronics. Add in cards reduce footprint of main circuit board and enable use of 2 layer board. Add in cards also allow for easy replace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
2018-02-15 small fixes for disconnects
2018-02-15 remove drill hole files
2018-02-15 add mounting holes to add in card, make zones, move current limiting resistor
2018-02-15 random mods
2018-02-15 add output zips
2018-02-17 rotate connectors on newMux
2018-02-17 fix newMUX lib paths
2018-02-17 rotate connectors on base1x
2018-02-17 fix base1x sharelibs link
2018-02-17 go back to old 30x30 springpins layout
2018-02-17 go back to 28x28 layout
2018-02-17 spruce up spring pin boards
2018-02-17 move arduino headers into myparts
2018-02-18 fix some clearance issues on base1x
2018-03-01 starting on ethercat board pin boards rotated base1x zones fixed
2018-03-16 update farnell codes
2018-03-21 upgrade syms and layouts to kicad5
2018-04-18 add dbg substrate layout and 8x1 backplane
2018-04-19 add dbg adapter
2018-04-19 fix 28x28 and start on mrg adapter
2018-04-20 mrg adapter board done
2018-04-20 update silk before order 629bf0f
2018-04-20 fix dbg board adapter
2018-04-20 add substrate markers
2018-05-01 update pcbs
2018-10-15 use CERN OHLv1.2
2018-10-30 add substrate holder model, create kicad projects for MIT adapter boards
2018-10-30 move substrate holder folder
2018-10-30 add top level geometry generator for substrate holder
2018-10-30 add substrate holder stl
2018-11-19 first try at making the caps springy
2018-12-21 update kicad and add logos
2019-01-14 MIT redesign in progress
2019-01-15 base 1x revisions
2019-01-15 fix up bus connections
2019-01-15 cut right mux connector in half
2019-01-15 work sync
2019-01-16 base1x doneish
2019-01-17 new base1x layed out, mux updated and re-layed out
2019-01-17 adapter and photodiode board for mit
2019-01-18 clean up mit springpin board names
2019-01-18 try to fix silkscreen strangeless
2019-01-26 update holder for mit
2019-01-26 add MIT build files
2019-01-27 improve PCB lock in
2019-01-27 update connector components and design printed bottom header shroud
2019-01-27 add shroud stl
2019-01-27 improve bottom shroud
2019-01-28 design top shroud
2019-01-28 top shroud becomes thinner
2019-01-28 embiggen clips
2019-01-31 fix up MRG substrate holder
2019-02-01 fix MRG cap
2019-02-01 turn shroud code into modules
2019-02-17 make MKRPOEPB
2019-04-03 wip on new hardware
2021-01-23 moving repository
2021-01-25 creating photos for comparison
2021-01-25 edits to base8x
2021-01-27 Replicating files to try on my own
2021-01-27 My work implementing resistor for sensor
2021-01-28 adding ssr and sensor
2021-02-02 SSR Changes
