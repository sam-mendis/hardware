# Repository sam-mendis/hardware

File README.md:

# hardware
Hardware disign files, for use with the [KiCAD EDA](http://kicad-pcb.org/)

## KiCad design Myattempt/base8x/base8x.kicad_pcb

Parts:
C1: 1uF; C_1206_3216Metric
D1, D2: BPW21; farnellCode 1045427
J1: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Horizontal; farnellCode 2215290
J2, J4: GS3; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
J3, J6: Conn_02x14_Counter_Clockwise; PinSocket_2x14_P2.54mm_Vertical
J7, J8: Conn_02x06_Counter_Clockwise; PinHeader_2x06_P2.54mm_Vertical
J9: Screw_Terminal_01x08; PhoenixContact_MC_1,5_8-GF-3.5_1x08_P3.50mm_Horizontal_Thre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; farnellCode 2776340+1793014
JP2, JP3, JP4, JP5, JP6: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: GREY@CHRISTOFORO.NET; logo
MK1, MK2: Mounting_Hole_PAD; MountingHole_2.2mm_M2_Pad
MK3, MK4, MK9, MK11: Mounting_Hole; MountingHole_6mm
MK5, MK7, MK8, MK12, MK13, MK14, MK15, MK16, MK17, MK18, MK19, MK20: Mounting_Hole; MountingHole_3.2mm_M3
MK6, MK10: Mounting_Hole; MountingHole_4.3mm_M4
P3, P4: CONN_01X02; PinHeader_1x02_P2.54mm_Vertical
R1, R2: 1.2K; R_1206_3216Metric; farnellCode 2073370
R3, R4: 10K; R_1206_3216Metric; farnellCode 2073607
R5: 1; R_2512_6332Metric; farnellCode 2663692
Raspberry_header1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
Resistor1: 4.7k; R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal
TP1, TP2, TP3, TP4, TP5, TP6: Test_Point; Test_Point_S1751-46R; farnellCode 2293786
Temp_sensor1: Conn_01x03_Female; PinSocket_1x03_P2.54mm_Vertical
U1: ADS1115; MSOP-10_3x3mm_P0.5mm; farnellCode 1762981

Connections:
+3V3: J3.3, J6.4, Raspberry_header1.1, Resistor1.2, Temp_sensor1.1
+5V: C1.1, J1.2, J3.1, J4.1 (A), J6.2, JP6.1, R1.2, R2.2, R3.2, Raspberry_header1.2, U1.8 (VDD)
/Vin: J1.9, J9.2, JP6.2
A_I+: J3.21, J6.22, J9.8
A_I-: J3.27, J6.28, J9.4, P4.2, R5.2, TP6.1
A_I-_EXT: J9.5, P3.1, P4.1, R5.1
A_V+: J3.23, J6.24, J9.7
A_V-: J3.25, J6.26, J9.6
A_V_D: J2.2 (C), J3.5, J6.6
A_V_D_EXT: J1.5, J2.3 (B)
A_V_D_LOC: J2.1 (A), TP5.1, U1.4 (AIN0)
CLK0: Raspberry_header1.7, Resistor1.1, Temp_sensor1.2
GND: C1.2, J1.6, J3.19, J3.20, J4.3 (B), J6.20, J9.1, JP3.2, JP5.2, MK1.1, MK2.1, P3.2, Raspberry_header1.6, Raspberry_header1.39, TP1.1, Temp_sensor1.3, U1.3 (GND); also elsewhere on the board
GPIO6: Raspberry_header1.31; also elsewhere on the board
MISO: J1.1, J3.13, J3.14, J6.14, Raspberry_header1.21
MOSI: J1.4, J3.15, J3.16, J6.16, Raspberry_header1.19
unnamed: D1.1 (K), JP2.2
unnamed: D1.2 (A), JP3.1
unnamed: D2.1 (K), JP4.2
unnamed: D2.2 (A), JP5.1
unnamed: J4.2 (C), R4.1
unnamed: JP2.1, R1.1, TP3.1, U1.6 (AIN2)
unnamed: JP4.1, R2.1, TP4.1, U1.7 (AIN3)
unnamed: R3.1, U1.2 (ALERT/RDY)
unnamed: R4.2, U1.1 (ADDR)
unnamed: TP2.1, U1.5 (AIN1)
SCK: J1.3, J3.17, J6.18
SCL: J1.8, J3.9, J3.10, J6.10, Raspberry_header1.5, U1.10 (SCL)
SCLK: Raspberry_header1.23
SDA: J1.7, J3.7, J3.8, J6.8, Raspberry_header1.3, U1.9 (SDA)
~A_CS: J1.10, J3.11, J6.12

Notes on the sheet:
POWER FLAGS
A-X
B-A
COMM_BUS
To Sourcemeter
External Power
This ADC will become ADS122C04 when it comes out to support analog inputs more negative than GND and I_sense will connect to AIN1
Current Sense Resistor

Board: 4 copper layers, 350.0 x 110.0 mm, 56 parts (3 on the bottom side), 33 nets.

Other parts of the board:
Resistor_SSR1: ?; R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal
SSR-Ithink1: 34.81-7048; Finder_34.81
SSR_connector1: Conn_01x02_Female; PinSocket_1x02_P2.54mm_Vertical

Their connections:
GND: SSR-Ithink1.A2; also elsewhere on the board
GPIO6: Resistor_SSR1.2; also elsewhere on the board
unnamed: Resistor_SSR1.1, SSR-Ithink1.A1
unnamed: SSR-Ithink1.11, SSR_connector1.1
unnamed: SSR-Ithink1.14, SSR_connector1.2

## KiCad design Myattempt/newMUX/newMUX.kicad_pcb

Parts:
C1: 0.1uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder; farnellCode 1759312
J1, J4: Conn_01x14; PinHeader_1x14_P2.54mm_Vertical; farnellCode 2037821
J2: Conn_02x06_Odd_Even; ESQ-106-44-G-D-004
J3: Conn_02x06_Odd_Even; ESQ-106-44-G-D; FarnellPart 1930232
JP1, JP6: Jumper_NC_Small; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2, JP3, JP4, JP5: Jumper_NC_Dual; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
R1, R2: 330R; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder; farnellCode 2073607
R3: 10K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder; farnellCode 2826357
R4: 680R; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder; farnellCode 2694489
RN1, RN4: 330R; R_Array_Convex_4x1206; digikey 744C083331JPCT-ND
TP1: Test_Point; Test_Point_S1751-46R; farnell code 2293786
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21: ASSR-1611; DIP-6_W7.62mm; farnellCode 1708441
U22: MCP23S17; DIP-28_W7.62mm; farnellCode 1292238

Connections:
+3V3: J1.2, J4.2
+5V: C1.1, J1.1, J4.1, JP2.1, JP3.1, JP4.1, JP5.1, R3.1, U22.9 (VDD)
/BOT: R2.2, U10.1, U20.1
/I1: J3.2, U12.6
/I2: J2.1, U13.6
/I3: J3.6, U14.6
/I4: J2.5, U15.6
/I5: J3.10, U16.6
/I6: J2.9, U17.6
/I7: J3.11, U18.6
/I8: J2.12, U19.6
/IB: J3.7, U20.6
/IT: J2.8, U11.6
/P1: RN4.5 (R4.2), U2.1, U12.1
/P2: RN4.6 (R3.2), U3.1, U13.1
/P3: RN4.7 (R2.2), U4.1, U14.1
/P4: RN4.8 (R1.2), U5.1, U15.1
/P5: RN1.1 (R1.1), U6.1, U16.1
/P6: RN1.2 (R2.1), U7.1, U17.1
/P7: RN1.3 (R3.1), U8.1, U18.1
/P8: RN1.4 (R4.1), U9.1, U19.1
/RSense: J2.2, U21.5
/TOP: R1.2, U1.1, U11.1
/V1: J3.4, U2.6
/V2: J2.3, U3.6
/V3: J3.8, U4.6
/V4: J2.7, U5.6
/V5: J3.12, U6.6
/V6: J2.11, U7.6
/V7: J3.9, U8.6
/V8: J2.10, U9.6
/VB: J3.5, U10.6
/VT: J2.6, U1.6
/V_D_EN: R4.2, U21.1
A0: JP2.2, U22.15 (A0)
A1: JP3.2, U22.16 (A1)
A2: JP4.2, U22.17 (A2)
GND: C1.2, J1.10, J3.1, J3.3, J4.10, JP2.3, JP3.3, JP4.3, JP5.3, TP1.1, U1.2, U2.2, U3.2, U4.2, U5.2, U6.2, U7.2, U8.2, U9.2, U10.2, U11.2, U12.2, U13.2, U14.2, U15.2, U16.2, U17.2, U18.2, U19.2, U20.2, U21.2, U22.10 (VSS)
I+: J1.11, J4.11, U12.4, U13.4, U14.4, U15.4, U16.4, U17.4, U18.4, U19.4
I-: J1.14, J4.14, U11.4, U20.4
MISO: J1.7, J4.7, U22.14 (SO)
MOSI: J1.8, J4.8, U22.13 (SI)
unnamed: J1.6, JP1.2
unnamed: J4.6, JP6.1
unnamed: R1.1, U22.21 (GPA0)
unnamed: R2.1, U22.22 (GPA1)
unnamed: R3.2, U22.18 (~RESET~)
unnamed: R4.1, U22.23 (GPA2)
unnamed: RN1.5 (R4.2), U22.8 (GPB7)
unnamed: RN1.6 (R3.2), U22.7 (GPB6)
unnamed: RN1.7 (R2.2), U22.6 (GPB5)
unnamed: RN1.8 (R1.2), U22.5 (GPB4)
unnamed: RN4.1 (R1.1), U22.4 (GPB3)
unnamed: RN4.2 (R2.1), U22.3 (GPB2)
unnamed: RN4.3 (R3.1), U22.2 (GPB1)
unnamed: RN4.4 (R4.1), U22.1 (GPB0)
SCK: J1.9, J4.9, U22.12 (SCK)
SCL: J1.5, J4.5
SDA: J1.4, J4.4
V+: J1.12, J4.12, U2.4, U3.4, U4.4, U5.4, U6.4, U7.4, U8.4, U9.4
V-: J1.13, J4.13, U1.4, U10.4
V_D: J1.3, J4.3, U21.6
~CS: JP1.1, JP5.2, JP6.2, U22.11 (~CS~)

Notes on the sheet:
ADDRESS SELECTION
POWER FLAGS
BOARD TYPE DETECTION
CONNECTORS TO SPRING PIN BOARD
RIGHT SIDE BUS CONNECTIONS
LEFT SIDE BUS CONNECTIONS
*R Networks become 160R for 3.3V supply

Board: 4 copper layers, 40.0 x 89.0 mm, 40 parts (15 on the bottom side), 63 nets.

## KiCad design KiCAD/MKRPOEPB/MKRPOEPB.kicad_pcb

Board: 2 copper layers, 20.0 x 25.0 mm, 8 parts (4 on the bottom side), 6 nets.

Parts:
D1, D2: DF01M; Diode_Bridge_Vishay_DFS
D3: D_TVS; D_SMA-SMB_Universal_Handsoldering
G1: grey@mutovis.com; text
H1, H2: MountingHole; MountingHole_2.2mm_M2
J1: UDE_PoE; RJ45_UDE_PoE
J2: Conn_01x02; PinHeader_1x02_P2.54mm_Horizontal

Connections:
unnamed: D1.1, D2.1, D3.1, J2.2
unnamed: D1.2, D2.2, D3.2, J2.1
unnamed: D1.3, J1.R9
unnamed: D1.4, J1.R10
unnamed: D2.3, J1.R7
unnamed: D2.4, J1.R8

## KiCad design KiCAD/springPinsMITBig/springPinsMITBig.kicad_pcb

Parts:
J1: CONN_02X06; TSSH-106-01-T-D-04
J2: CONN_02X06; TSSH-106-01-T-D
JP1: Jumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
L1: grey@mutovis.com; text
R1: 200k; R_1206_3216Metric
TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP15, TP16, TP17, TP18, TP19, TP20: TEST; S25-022+P25-4023

Connections:
/BCu: J2.3, JP1.1 (A)
/FCu: J2.1, JP1.3 (B)
/I1: J2.2, TP20.1
/I2: J1.1, TP8.1
/I3: J2.6, TP18.1
/I4: J1.5, TP6.1
/I5: J2.10, TP16.1
/I6: J1.9, TP4.1
/IB: J2.7, TP10.1
/IT: J1.8, TP9.1
/RH: J1.2, R1.2
/V1: J2.4, TP19.1
/V2: J1.3, TP7.1
/V3: J2.8, TP17.1
/V4: J1.7, TP5.1
/V5: J2.12, TP15.1
/V6: J1.11, TP3.1
/VB: J2.5, TP12.1
/VT: J1.6, TP11.1
GND: JP1.2 (C), R1.1

Notes on the sheet:
Board Type Encoding Resistor

Board: 2 copper layers, 25.1 x 25.1 mm, 22 parts (5 on the bottom side), 20 nets.

Other parts of the board:
L1#2: grey@mutovis.com; text

## KiCad design KiCAD/MITDiodeArray/MITDiodeArray.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6: D_Photo; BPW34
W1, W2, W3, W4, W5, W6, W7, W10, W11, W12, W13, W14, W15, W16, W17, W20: TEST_1P; SolderWirePad_single_SMD_4.7x3.2mm

Connections:
/com: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), W1.1, W10.1, W11.1, W20.1
unnamed: D1.2 (A), W2.1, W12.1
unnamed: D2.2 (A), W3.1, W13.1
unnamed: D3.2 (A), W4.1, W14.1
unnamed: D4.2 (A), W5.1, W15.1
unnamed: D5.2 (A), W6.1, W16.1
unnamed: D6.2 (A), W7.1, W17.1

Board: 2 copper layers, 25.1 x 25.1 mm, 24 parts (15 on the bottom side), 7 nets.

Other parts of the board:
text: G***; text
text#2: G***; text
